<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
<path>$WS_DIR$\four_mic_array_receiver.ewp</path>
  </project>
  <batchBuild />
</workspace>
